# Keil uVision project NewFW_SVN.uvprojx, settings and files
target NewFW (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: stm32f4_bootloader_v1_2 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\MCU;..\MCU\include;..\RTOS;..\RTOS\include;..\RTOS\Components;..\RTOS\Components\finsh\include;..\RTOS\Components\lwip\include;..\RTOS\Components\json\include;..\RTOS\Components\freemodbus\include;..\User\BSP;..\User\StdLib;..\User\StdTest;..\User\UserApp;..\User\BoardCal;..\User\UserTest
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep *.o(FSymTab) --keep *.o(VSymTab)
  group MCU
    ../MCU/source/: misc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c system_stm32f4xx.c startup_stm32f4xx.s
  group RTOS
    ../RTOS/source/: board.c usart.c serial.c clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c backtrace.c cpuport.c div0.c showmem.c context_rvds.S completion.c dataqueue.c
  group Finsh_components
    ../RTOS/Components/finsh/source/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group Lwip_components
    ../RTOS/Components/lwip/source/: api_lib.c api_msg.c autoip.c def.c dhcp.c dns.c err.c etharp.c ethernetif.c icmp.c igmp.c inet.c inet_chksum.c init.c ip.c ip_addr.c ip_frag.c mem_lwip.c memp.c netbuf.c netdb.c netif.c netifapi.c pbuf.c raw.c slipif.c sockets.c stats.c sys.c sys_arch.c tcp.c tcp_in.c tcp_out.c tcpip.c timers.c udp.c
  group BSP
    ../User/BSP/: bsp_iic.c bsp_eeprom.c bsp_88e6060.c
  group StdLib
    ../User/StdLib/: stdlib_limit.c
  group UserApp
    ../User/UserApp/: userProcess.c application.c startup.c LimitCfg.c networkcommu.c networkcfg.c networkprocess.c networkupdate.c
  group Doc
    ../User/Doc/: readme.txt Version.txt
software components: CMSIS:CORE 3.30.0
